Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: 108304.IFC
Time: 2024-06-06T08:03:16
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 101222_Default
In: Default Storey
Material: PE

# IfcBuildingElementProxy: 104175_Default (9)
In: Default Storey
Name | Material
4 x 104175_Default
5 x 104175_Default | Douka
